# Keil uVision project STM32F407_USB_MSC_DEVICE.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407_USB_MSC_DEVICE +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,STM32F407xx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\CMSIS;..\USER\inc;..\FreeRtos\include;..\FreeRtos\portable\RVDS\ARM_CM4F;..\FWLIB\inc;..\FWLIB\src;..\USER\uart;..\USER\debug;..\USER\system;..\USER\debug;..\USER\wifi;..\sdk;..\fatfs;..\module\W25QXX;..\USER\usb;..\USER\usb\STM32_USB_Device_Library\Core\inc;..\USER\usb\STM32_USB_Device_Library\Class\cdc\inc;..\USER\usb\STM32_USB_OTG_Driver\inc;..\USER\usb\USB_APP;..\USER\usb\STM32_USB_Device_Library\Class\msc\inc;..\module\W25QXX
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/src/: hc595.c key.c led.c main.c rtc.c spi.c systick.c usart1.c usart2.c w25q64.c ili9486.c lcd.c dma.c sdio_sdcard.c sys.c delay.c
  group CMSIS
    ../CMSIS/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group FreeRtos_Code
    ../FreeRtos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRtos_Potable
    ../FreeRtos/portable/MemMang/: heap_4.c
    ../FreeRtos/portable/RVDS/ARM_CM4F/: port.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group uart
    ../USER/uart/: uart.c
  group system
    ../USER/system/: system.c
  group wifi
    ../USER/wifi/: wifi.c
  group debug
    ../USER/debug/: debug.c
  group sdk
    ../sdk/: sdk.c
  group fatfs
    ../fatfs/: ff.c ffsystem.c ffunicode.c diskio.c
  group USB_OTG
    ../USER/usb/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_DEVICE
    ../USER/usb/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USER/usb/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_APP
    ../USER/usb/USB_APP/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group w25qxx
    ../module/W25QXX/: w25qxx.c
